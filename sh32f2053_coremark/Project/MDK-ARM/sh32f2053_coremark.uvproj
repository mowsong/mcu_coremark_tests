# Keil uVision project sh32f2053_coremark.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: SH32F2053 Sinowealth
  cpu: IRAM(0x20000000-0x20001FFF) IRAM2(0x10000000-0x10003FFF) IROM(0x0000000-0x003FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: sh32f2053_coremark
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USING_USER_CFG, ITERATIONS=4000
  c include: ..\..\Source\User;..\..\Source\Libraries\CMSIS\Include;..\..\Source\Libraries\CMSIS\Device\Sinowealth\SH32F2xx\Include;..\..\Source\Libraries\SH32F2xx_sa0_StdPeriph_Driver\1.0\inc;..\..\..\coremark;..\..\Source\User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group User
    ../../Source/User/: sh32f2053_int.c sh32f2053_main.c sh32f2053_periph_init.c sh32f2053_config.h core_portme.c
  group Startup
    ../../Source/User/: startup_sh32f2053_keil.s
  group CMSIS
    ../../Source/Libraries/CMSIS/Device/Sinowealth/SH32F2xx/Source/: system_SH32F2053.c
  group Debug
    ../../Source/Libraries/CMSIS/Device/Sinowealth/SH32F2xx/Source/: SH32F2053_retarget.c
  group StdPeriph_Driver
    ../../Source/Libraries/SH32F2xx_sa0_StdPeriph_Driver/1.0/src/: sh32f2xx_rcc.c sh32f2xx_iwdt.c sh32f2xx_gpio.c sh32f2xx_uart.c
  group coremark
    ../../../coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
