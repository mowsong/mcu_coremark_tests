# Keil uVision project main.uvprojx, settings and files
target mr88f001_24m_O3_time_loop2 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MR88F001 MRSEMI
  pack: MRSEMI.MR88F.2.0.3
  cpu: IRAM(0x20000000,0x04000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: mr88f001_coremark
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SYSTEM_CLOCK_24M, ITERATIONS=500
  c misc: --loop_optimization_level=2
  c include: ..\coremark;..\mr88f001_coremark
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c retarget.c core_portme.c
  group coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
target mr88f001_24m_O3_time (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MR88F001 MRSEMI
  pack: MRSEMI.MR88F.2.0.3
  cpu: as above
  output: mr88f001_coremark
  c flags: as above
  c define: SYSTEM_CLOCK_24M, ITERATIONS=500
  c include: ..\coremark;..\mr88f001_coremark
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
target mr88f001_24m_O3 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MR88F001 MRSEMI
  pack: MRSEMI.MR88F.2.0.3
  cpu: as above
  output: mr88f001_coremark
  c flags: as above
  c define: SYSTEM_CLOCK_32M, ITERATIONS=500
  c include: ..\coremark;..\mr88f001_coremark
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
target mr88f001_32m_O3_time_loop2 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MR88F001 MRSEMI
  pack: MRSEMI.MR88F.2.0.3
  cpu: as above
  output: mr88f001_coremark
  c flags: as above
  c define: SYSTEM_CLOCK_32M, ITERATIONS=500
  c misc: --loop_optimization_level=2
  c include: ..\coremark;..\mr88f001_coremark
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
target mr88f001_32m_O3_time (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MR88F001 MRSEMI
  pack: MRSEMI.MR88F.2.0.3
  cpu: as above
  output: mr88f001_coremark
  c flags: as above
  c define: SYSTEM_CLOCK_32M, ITERATIONS=500
  c include: ..\coremark;..\mr88f001_coremark
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
target mr88f001_32m_O3 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MR88F001 MRSEMI
  pack: MRSEMI.MR88F.2.0.3
  cpu: as above
  output: mr88f001_coremark
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SYSTEM_CLOCK_24M, ITERATIONS=500
  c include: ..\coremark;..\mr88f001_coremark
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
target mr88f001_16m_O3_time_loop2 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MR88F001 MRSEMI
  pack: MRSEMI.MR88F.2.0.3
  cpu: as above
  output: mr88f001_coremark
  c flags: as above
  c define: SYSTEM_CLOCK_16M, ITERATIONS=500
  c misc: --loop_optimization_level=2
  c include: ..\coremark;..\mr88f001_coremark
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
target mr88f001_16m_O3_time (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MR88F001 MRSEMI
  pack: MRSEMI.MR88F.2.0.3
  cpu: as above
  output: mr88f001_coremark
  c flags: as above
  c define: SYSTEM_CLOCK_16M, ITERATIONS=500
  c include: ..\coremark;..\mr88f001_coremark
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
target mr88f001_16m_O3 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MR88F001 MRSEMI
  pack: MRSEMI.MR88F.2.0.3
  cpu: as above
  output: mr88f001_coremark
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SYSTEM_CLOCK_16M, ITERATIONS=500
  c misc: --loop_optimization_level=2
  c include: ..\coremark;..\mr88f001_coremark
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 5.3.0, Device:Startup 0.0.1
