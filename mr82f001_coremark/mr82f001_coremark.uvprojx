# Keil uVision project mr82f001_coremark.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: MR82FX01DI/064 MRSEMI
  pack: MRSEMI.MR82Fx01.1.0.7
  cpu: IRAM(0x20000000,0x04000) IROM(0x00000000,0x40000) CPUTYPE("ARMV8MML") FPU3(SFPU) DSP CLOCK(12000000)
  output: mr82f001_coremark
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ITERATIONS=4000
  c include: .\simple_lib;..\coremark;..\mr82f001_coremark
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group src
    ./: main.c core_portme.c
  group simple_lib
    ./simple_lib/: pll.c
  group coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
software components: CMSIS:CORE 5.4.0, Device:Startup 0.0.1
