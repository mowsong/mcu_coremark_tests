<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32g070_coremark.ewp</path>
  </project>
  <batchBuild />
</workspace>
